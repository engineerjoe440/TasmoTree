# Repository engineerjoe440/TasmoTree

File README.md:

# TasmoTree 
*PCB Layout for Tasmota Controlled (ESP8266) Christmas Tree Miniature Village Display*

### Summary:
This project primarily contains the hardware considerations for a Tasmota-based ESP32-centric control system for a
custom Christmas Tree design which has multiple "layers" or "tiers" which each support and hold parts of a miniature
villiage.

### Design Render:
The finalized PCB render is shown here:

### License:
This project is ultimately a custom design, but should not be thought of as "private", it is licensed openly such that
anyone interested may consume the existing design and modify as desired.

## KiCad design TasmoTree/TasmoTree.kicad_pcb

Board: 2 copper layers, 99.6 x 99.6 mm, 24 parts (0 on the bottom side), 25 nets.

Parts:
 : MountingHole_2.7mm
 #2,  #3,  #4: MountingHole_2.7mm
C1: 100nF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C2: 10uF; CP_Radial_D4.0mm_P1.50mm
J1: POWER_IN; TerminalBlock_Altech_AK300-4_P5.00mm
J2: MOT_SW_CONN; TerminalBlock_Altech_AK300-3_P5.00mm
J3: MOTOR_POWER; TerminalBlock_Altech_AK300-2_P5.00mm
J4: LED_5MM_CONN; TerminalBlock_Altech_AK300-3_P5.00mm
J5: LED_CONN_1; TerminalBlock_Altech_AK300-3_P5.00mm
J6: LED_CONN_2; TerminalBlock_Altech_AK300-3_P5.00mm
Q1, Q2, Q3: PSMN027-100PS; TO255P1040X460X2890-3
R1, R2: R; Resistor_SMD+THTuniversal_0805to1206_RM10_HandSoldering
S1: EC2-12NU; RELAY_7-1393243-9
SW1: Rotary_Encoder_Switch; XDCR_PEC11R-4215F-S0024
U1: ESP8266; ESP8266_NODEMCU
U2: LD1117S33TR_SOT223; TO-220-3_Vertical
U3, U4, U5: LED-DRIVER; LDD-L-MEANWELL

Connections:
12VP: C1.1, J1.2, J2.1, J4.1, U2.3
GNDPWR: C1.2, C2.2, J1.1, J1.3, Q1.3, Q2.3, Q3.3, SW1.1, SW1.COM, SW1.S1, SW1.S2, U1.10, U1.14, U1.22, U1.29, U2.1, U3.4, U4.4, U5.4
unnamed: C2.1, R1.1, R2.1, U1.11, U1.21, U1.30, U2.2
unnamed: J1.4, U3.1, U4.1, U5.1
unnamed: J2.2, J3.1, S1.12, S1.24, S1.A2
unnamed: J2.3, S1.21
unnamed: J3.2, S1.14, S1.22
unnamed: J4.2, Q3.2
unnamed: J4.3, Q2.2
unnamed: J5.1, U5.6
unnamed: J5.2, U5.5
unnamed: J5.3, U4.6
unnamed: J6.1, U4.5
unnamed: J6.2, U3.6
unnamed: J6.3, U3.5
unnamed: Q1.1, U1.16
unnamed: Q1.2, S1.11, S1.A1
unnamed: Q2.1, U1.17
unnamed: Q3.1, U1.24
unnamed: R1.2, SW1.A, U1.26
unnamed: R2.2, SW1.2, U1.25
unnamed: SW1.B, U1.23
unnamed: U1.18, U5.3
unnamed: U1.27, U4.3
unnamed: U1.28, U3.3

## Commit log

2020-11-28 started design
2020-11-28 added logo and updated the design with capacitor info
2020-11-28 fixed logo path
2020-11-29 started pinout design and created symbol for led drivers
2020-12-02 finished basic schematic layout
2020-12-02 resolved some issues with the ESP8266 symbol pinouts
2020-12-02 added missing rotary encoder
2020-12-04 rough design of pcb layout added
2020-12-05 generated gerber files and submitted for fabrication
2020-12-05 added renders
2020-12-12 rev-2 design completed and ordered
2021-05-29 bumped to KiCAD 5+, added workflow for test
2021-05-29 attempt to resolve syntax error
2021-05-29 attempt to resolve error with missing docs folder
2021-05-30 attempt to alter workflow to commit output to main branch
2021-05-30 didn't add all the files?
2021-05-30 Add changes
2021-05-30 reverted... that didn't work. :(
2021-12-02 test new yml
2021-12-02 fix typo
2021-12-02 try something new
2021-12-02 resolved issue
2021-12-02 fix branch name
2021-12-02 fixed path

Notices in the files:
TasmoTree/TasmoTree.kicad_pcb:
©Stanley Solutions | 2020
